# Keil uVision project project.uvprojx, settings and files
target rtthread (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52840_XXAA, RT_USING_ARMLIBC, SOFTDEVICE_PRESENT, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, CONFIG_GPIO_AS_PINRESET
  c misc: --reduce_paths
  c include: packages\nrf5x_sdk-v16.1.0\components\ble\ble_link_ctx_manager;packages\nrf5x_sdk-v16.1.0\components\libraries\log;packages\nrf5x_sdk-v16.1.0\components\libraries\sensorsim;rt-thread\components\drivers\include;applications;rt-thread\libcpu\arm\common;packages\nrf5x_sdk-v16.1.0\components\libraries\strerror;packages\nrf5x_sdk-v16.1.0\components\ble\nrf_ble_qwr;rt-thread\components\drivers\spi;packages\nrf5x_sdk-v16.1.0\components\libraries\atomic;rt-thread\include;packages\nrf5x_sdk-v16.1.0\components\ble\ble_services\ble_nus;packages\nrf5x_sdk-v16.1.0\components\libraries\balloc;rt-thread\components\utilities\ulog;packages\nrfx-latest\mdk;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;packages\nrf5x_sdk-v16.1.0\components\ble\common;libraries\cmsis\include;packages\nrf5x_sdk-v16.1.0\components\libraries\util;packages\nrfx-latest\drivers;packages\nrf5x_sdk-v16.1.0\components\ble\nrf_ble_gatt;packages\nrfx-latest;rt-thread\components\libc\posix\io\eventfd;packages\nrf5x_sdk-v16.1.0\components\libraries\memobj;board;packages\nrf5x_sdk-v16.1.0\integration\nrfx\legacy;rt-thread\components\libc\compilers\common\include;packages\nrfx-latest\hal;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\drivers\include;packages\nrf5x_sdk-v16.1.0\components\softdevice\common;rt-thread\components\libc\posix\ipc;packages\nrfx-latest\drivers\src;rt-thread\components\libc\compilers\common\extension;packages\nrf5x_sdk-v16.1.0\components\libraries\atomic_flags;libraries\drivers;packages\nrf5x_sdk-v16.1.0\components\softdevice\s140\headers;packages\nrf5x_sdk-v16.1.0\components\ble\ble_services\ble_lbs;rt-thread\components\finsh;rt-thread\components\libc\posix\io\epoll;.;packages\nrf5x_sdk-v16.1.0\components\libraries\experimental_section_vars;rt-thread\components\drivers\include;packages\nrfx-latest\drivers\include;packages\nrf5x_sdk-v16.1.0\components\libraries\log\src;packages\nrf5x_sdk-v16.1.0\components\softdevice\s140\headers\nrf52;rt-thread\components\drivers\include;rt-thread\components\libc\posix\io\poll;packages\nrf5x_sdk-v16.1.0\components\ble\ble_advertising
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002ae8 size 0x3d518
  group Applications
    applications/: application.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/: board.c
    libraries/drivers/: drv_gpio.c drv_spi.c drv_spim.c drv_uart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group nrf_Drivers
    packages/nrfx-latest/drivers/src/: nrfx_usbd.c nrfx_qdec.c nrfx_dppi.c nrfx_ppi.c nrfx_clock.c nrfx_nvmc.c nrfx_uart.c nrfx_twi_twim.c nrfx_qspi.c nrfx_saadc.c nrfx_power.c nrfx_timer.c nrfx_usbreg.c nrfx_comp.c nrfx_wdt.c nrfx_rtc.c nrfx_spis.c nrfx_adc.c nrfx_rng.c nrfx_systick.c nrfx_egu.c nrfx_i2s.c nrfx_uarte.c nrfx_spim.c nrfx_twis.c nrfx_lpcomp.c nrfx_twi.c nrfx_pdm.c nrfx_temp.c nrfx_ipc.c nrfx_twim.c nrfx_gpiote.c nrfx_nfct.c nrfx_pwm.c nrfx_spi.c
    packages/nrfx-latest/mdk/: arm_startup_nrf52840.s system_nrf52840.c
  group SOFTDEVICE
    packages/nrf5x_sdk-v16.1.0/components/libraries/util/: app_error_weak.c app_util_platform.c app_error.c
    packages/nrf5x_sdk-v16.1.0/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    packages/nrf5x_sdk-v16.1.0/components/ble/common/: ble_srv_common.c ble_advdata.c ble_conn_state.c
    packages/nrf5x_sdk-v16.1.0/components/libraries/strerror/: nrf_strerror.c
    packages/nrf5x_sdk-v16.1.0/components/ble/ble_advertising/: ble_advertising.c
    packages/nrf5x_sdk-v16.1.0/components/libraries/sensorsim/: sensorsim.c
    packages/nrf5x_sdk-v16.1.0/components/libraries/atomic_flags/: nrf_atflags.c
    packages/nrf5x_sdk-v16.1.0/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    packages/nrf5x_sdk-v16.1.0/components/softdevice/common/: nrf_sdh.c
    packages/nrf5x_sdk-v16.1.0/components/libraries/experimental_section_vars/: nrf_section_iter.c
    packages/nrf5x_sdk-v16.1.0/rtt_adapter/: ble_conn_params_rtt.c nrf_sdh_ble_rtt.c ble_app_uart.c
    packages/nrf5x_sdk-v16.1.0/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    packages/nrf5x_sdk-v16.1.0/components/ble/ble_services/ble_nus/: ble_nus.c
    packages/nrf5x_sdk-v16.1.0/integration/nrfx/legacy/: nrf_drv_clock.c
    packages/nrf5x_sdk-v16.1.0/components/libraries/atomic/: nrf_atomic.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
target softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: s140_nrf52_7.0.1_softdevice.hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52840_XXAA, USE_APP_CONFIG, RT_USING_ARM_LIBC  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002300 size 0x40000
  link misc: --diag_suppress 6330
